# Keil uVision project stm32f4_withFreeRTOS.uvprojx, settings and files
target Normal (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4_withFreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx
  c include: ..\fml;..\mdl;..\mdl\rttviewer;..\Utilities;..\bsp;..\components\STM32F4xx_HAL_Driver\Inc;..\components\STM32F4xx_HAL_Driver\Inc\Legacy;..\components\STM32F4xx_HAL_Driver\Src;..\components;..\app;..\components\CMSIS\Core\Include;..\components\CMSIS\Core_A\Include;..\components\CMSIS\Device\ST\STM32F4xx\Include;..\components\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group components/startup
    ../components/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group components/utilities
    ../components/: stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c
    ../components/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group components/driver
    ../components/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c
  group app
    ../app/: main.c
  group bsp
    ../bsp/: bsp_systick.c bsp_flash.c bsp_clock.c bsp_conf.h
  group fml
    ../fml/: lnprotocol.c lnprotocol_std.c system_param.c version.c version.h
  group mdl
    ../mdl/rttviewer/: clog.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../mdl/: board.c
  group uti
    ../Utilities/: crc.c
